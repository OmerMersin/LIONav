Commit message: fix(model): adjust mesh material and remove redundant os_sensor visual

File: ros2_ws/src/my_drone_description/urdf/drone_body.urdf (robot description, URDF)
Before this commit: robot drone_model, 3 links, 2 joints
Links:
- link os_sensor: geometry 
